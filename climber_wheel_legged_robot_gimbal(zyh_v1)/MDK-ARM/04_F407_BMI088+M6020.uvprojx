# Keil uVision project 04_F407_BMI088+M6020.uvprojx, settings and files
target 04_F407_BMI088+M6020 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 04_F407_BMI088+M6020 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp/boards;../components/algorithm;../components/controller;../components/devices;../components/support;../application;../components/algorithm/Include;../Music;../shoot
  asm include: ../Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group board
    ../bsp/boards/: bsp_delay.c bsp_flash.c bsp_i2c.c bsp_imu_pwm.c bsp_laser.c bsp_led.c bsp_rc.c bsp_spi.c bsp_buzzer.c bsp_adc.c bsp_can.c bsp_dwt.c bsp_dwt.h
  group algorithm
    ../components/algorithm/: arm_cortexM4lf_math.lib user_lib.c sign_gengerator.c sign_gengerator.h kalman_filter.c kalman_filter.h ahrs.h AHRS_MiddleWare.h
  group controller
    ../components/controller/: pid.c controller.c controller.h slidingmodec.c slidingmodec.h
  group devices
    ../components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver_middleware.c ist8310driver.c motor.c motor.h
  group application
    ../application/: struct_typedef.h gimbal_behaviour.c gimbal_behaviour.h gimbal_task.c gimbal_task.h CAN_receive.c CAN_receive.h remote_control.c remote_control.h Remote_rec_task.c Remote_rec_task.h IMU_solve.c IMU_solve.h IMU_task.c IMU_task.h IMU.h macro_typedef.h AutoGimbal.c AutoGimbal.h Keyboard.c Keyboard.h
  group Music
    ../Music/: music_task.c music_task.h music_typedef.h music.h music_start.c music_start.h music_calibrate.h music_rc_offline.c music_rc_offline.h music_see_you_again.c music_see_you_again.h
    ../components/support/: fifo.c fifo.h
  group shoot
    ../shoot/: shoot.c shoot.h shoot_fric_trigger.c shoot_fric_trigger.h shoot_task.c shoot_task.h
software components: CMSIS:CORE 5.6.0
