# Keil uVision project climber_wheel_legged_robot_chassis.uvprojx, settings and files
target climber_wheel_legged_robot_chassis (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: climber_wheel_legged_robot_chassis.axf +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../BSP;../Chassis;../Controller;../IMU;../Device;../DSP/Include;../DSP/Include/dsp;../Message;../Judge;../Music
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/: bsp_rc.c bsp_rc.h bsp_delay.c bsp_delay.h bsp_can.c bsp_can.h bsp_buzzer.c bsp_buzzer.h bsp_BuzzerSongs.c bsp_BuzzerSongs.h
  group Chassis
    ../Chassis/: struct_typedef.h robot_param_balanced_infantry.h chassis_task.c chassis_task.h chassis_balance_extra.c chassis_balance_extra.h computer_rec.c computer_rec.h State_chexk_task.c State_chexk_task.h TOF_distance.c TOF_distance.h chassis_power_control.c chassis_power_control.h talk_task.c talk_task.h
  group Controller
    ../Controller/: pid.c pid.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h user_lib.c user_lib.h
  group IMU
    ../IMU/: MahonyAHRS.c MahonyAHRS.h BMI088reg.h BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h IMU_task.c IMU_task.h
  group Message
    ../Message/: CAN_cmd_damiao.h CAN_cmd_damiao.c motor.c motor.h robot_typedef.h CAN_receive.c CAN_receive.h
  group Judge
    ../Judge/: judge_paint_task.h judge_paint_task.c judge_send_app.c judge_send_app.h crc_check.c crc_check.h
  group Music
    ../Music/: Music_task.c Music_task.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
